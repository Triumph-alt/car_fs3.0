# Keil uVision project SEEKFREE.uvproj, settings and files
target STC32G12K128 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  link misc: REMOVEUNUSED
  group user_c
    ../USER/src/: isr.c main.c OLED.c at24c16.c transfer.c uart.c encoder.c filter.c motor.c maths.c electromagnetic_tracking.c pid.c
  group user_h
    ../USER/inc/: isr.h OLED.h OLED_Font.h at24c16.h transfer.h uart.h encoder.h filter.h motor.h maths.h electromagnetic_tracking.h pid.h
  group startup
    ../libraries/: board.c common.c START251.A51 STC32_MDU32_V1.1.LIB
  group seekfree_libraries
    ../seekfree_libraries/: zf_adc.c zf_delay.c zf_exti.c zf_function.c zf_gpio.c zf_iic.c zf_mdu16.c zf_nvic.c zf_pwm.c zf_spi.c zf_tim.c zf_uart.c zf_fifo.c
  group seekfree_peripheral
    ../seekfree_peripheral/: headfile.h SEEKFREE_IMU963RA.c
